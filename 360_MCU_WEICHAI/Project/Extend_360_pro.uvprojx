# Keil uVision project Extend_360_pro.uvprojx, settings and files
target Extend_360_Pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Extend_360_pro +hex
  AfterMake: mergebin.bat $K\ARM\ARMCC\bin\fromelf.exe Extend_360_Pro
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, APP_AREA
  c include: ..\Inc;..\Inc\core;..\App;..\Lib\app
  library: MicroLIB
  memory RVCT4: ROM 0x8006400 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x400
  memory RVCT10: RAM 0x20000400 size 0x4c00
  group Startup
    ../Inc/core/: startup_stm32f10x_md.s
  group Library
    ../Lib/app/: adc.c can.c can_diag_protocol.c can_did.c can_dtc.c can_net_layer.c gpio.c iflash.c misc.c timer.c usart.c arch.s upgrade.c diag_upgrade.c
  group Application
    ../App/: message.c main.c function.c
software components: CMSIS:CORE 5.1.1
