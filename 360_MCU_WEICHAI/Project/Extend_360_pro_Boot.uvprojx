# Keil uVision project Extend_360_pro_Boot.uvprojx, settings and files
target Extend_360_Pro_Boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Extend_360_pro_Boot +hex
  AfterMake: mergebin.bat $K\ARM\ARMCC\bin\fromelf.exe Extend_360_Pro_Boot
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, APP_AREA
  c include: ..\Inc;..\Inc\core;..\Lib\boot;..\Boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6400
  memory RVCT9: RAM 0x20000000 size 0x400
  memory RVCT10: RAM 0x20000400 size 0x4c00
  group Startup
    ../Inc/core/: startup_stm32f10x_md.s
  group library
    ../Lib/boot/: can.c can_diag_protocol.c can_net_layer.c gpio.c iflash.c misc.c timer.c arch.s usart.c diag_upgrade.c can_dtc.c
  group Application
    ../Boot/: function.c main.c message.c
software components: CMSIS:CORE 5.1.1
